v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {/foss/designs/004_Real_Circuits/linkwtz_riley_crossover_pretl_OTA.sym} 0 0 0 0 {name=x1}
