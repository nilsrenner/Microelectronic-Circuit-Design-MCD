** sch_path: 004_Real_Circuits/002_version_no_enable/ota-5t_tb-ac_no_ena.sch
* (c) 2024-2025 Harald Pretl, Apache-2.0 license
**.subckt ota-5t_tb-ac_no_ena
Vdd v_dd GND 1.5
Vss v_ss GND 0
C1 v_out v_ss 50f m=1
Vin v_in v_ss dc 0.8 ac 1
I0 v_dd net1 20u
.save v(v_in)
.save v(v_out)
I1 v_ss v_out dc 0 ac 0
x1 v_dd v_out v_in v_out net1 v_ss ota-5t_no_ena_copy
**** begin user architecture code
 .lib cornerMOSlv.lib mos_tt

 .include [file rootname [xschem get schname]].save



.temp 27
.control
option sparse
save all
op
write ota-5t_tb-ac.raw
set appendwrite

ac dec 101 100 100MEG
write ota-5t_tb-ac.raw

wrdata real_circuit_ac_analysis_no_ena.txt db(v_out)

plot 20*log10(v_out)

meas ac dcgain MAX vmag(v_out) FROM=10 TO=10k
let f3db = dcgain/sqrt(2)
meas ac fbw WHEN vmag(v_out)=f3db FALL=1
let gainerror=(dcgain-1)/1
print dcgain
print fbw
print gainerror

noise v(v_out) Vin dec 101 1k 100MEG
print onoise_total

.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
