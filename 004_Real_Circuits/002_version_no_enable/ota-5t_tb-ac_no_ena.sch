** sch_path: 004_Real_Circuits/002_version_no_enable/ota-5t_tb-ac_no_ena.sch
* (c) 2024-2025 Harald Pretl, Apache-2.0 license
**.subckt ota-5t_tb-ac_no_ena
Vdd v_dd GND 1.5
Vss v_ss GND 0
C1 v_out v_ss 50f m=1
Vin v_in v_ss dc 0.8 ac 1
I0 v_dd net1 20u
.save v(v_in)
.save v(v_out)
I1 v_ss v_out dc 0 ac 0
x1 v_dd v_out v_in v_out net1 v_ss ota-5t_no_ena_copy
**** begin user architecture code
 .lib cornerMOSlv.lib mos_tt



.temp 27
.control
option sparse
save all

* DC-OP, kein raw nötig für spr
op

* Ab hier: ASCII für AC-Analyse
set filetype=ascii
set appendwrite = false    ; optional, aber klarer

* AC-Analyse, direkt in neue Datei schreiben
ac dec 101 100 100MEG
write ota-5t_tb-ac.raw all

plot 20*log10(v_out)

meas ac dcgain MAX vmag(v_out) FROM=10 TO=10k
let f3db = dcgain/sqrt(2)
meas ac fbw WHEN vmag(v_out)=f3db FALL=1
let gainerror=(dcgain-1)/1
print dcgain
print fbw
print gainerror

* Noise-Analyse: entweder eigene Datei oder nur Terminal
noise v(v_out) Vin dec 101 1k 100MEG
* optional: eigene raw-Datei
* write ota-5t_tb-noise.raw all
print onoise_total

.endc


 .include [file rootname [xschem get schname]].save

**** end user architecture code
**.ends
.GLOBAL GND
.end
